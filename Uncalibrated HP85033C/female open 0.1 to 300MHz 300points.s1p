# HZ S RI R 50
! Worked out from all points (one-port):
!   303 points, 100 kHz to 3 GHz, reference 50 ohm
!   lowest |S11| = -3.2 dB at 1.997 GHz (marker M1), VSWR 5.57, Z = 10.7 + j21.3 ohm
!   |S11| at or under -10 dB: nowhere
!   the Smith chart shows 1.729 GHz to 2.245 GHz only
!   S11 on the Smith chart (normalised r, x): 1.729 GHz: 4.05, -4.27; 1.838 GHz: 0.15, -0.75; 1.947 GHz: 0.17, +0.07; 2.066 GHz: 0.43, +1.32; 2.245 GHz: 0.18, -0.99
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! magnitudes (dB):
! f  S11
! 100 kHz  -0.2
! 10.03 MHz  1.5
! 19.97 MHz  0.7
! 29.9 MHz  0.5
! 149.1 MHz  -0.8
! 377.6 MHz  -0.3
! 546.4 MHz  -0.3
! 755 MHz  -1.9
! 914 MHz  -1.0
! 1.053 GHz  -2.6
! 1.133 GHz  -2.9
! 1.301 GHz  -1.8
! 1.5 GHz  -2.2
! 1.639 GHz  -2.7
! 1.729 GHz  -2.0
! 1.838 GHz  -1.7
! 1.878 GHz  -2.1
! 1.947 GHz  -2.9
! 1.997 GHz  -3.2
! 2.066 GHz  -2.6
! 2.156 GHz  -1.6
! 2.245 GHz  -1.6
! 2.255 GHz  -1.6
! 2.364 GHz  -1.8
! 2.632 GHz  -0.5
! 2.732 GHz  0.2
! 2.93 GHz  -0.7
! 3 GHz  -0.4
