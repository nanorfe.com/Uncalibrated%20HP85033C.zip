# HZ S RI R 50
! Worked out from all points (one-port):
!   303 points, 100 kHz to 3 GHz, reference 50 ohm
!   lowest |S11| = -3.2 dB at 1.818 GHz (marker M1), VSWR 5.47, Z = 15.3 + j39.9 ohm
!   |S11| at or under -10 dB: nowhere
!   the Smith chart shows 1.55 GHz to 2.086 GHz only
!   S11 on the Smith chart (normalised r, x): 1.55 GHz: 0.78, -2.39; 1.768 GHz: 0.18, +0.33; 1.887 GHz: 1.24, +2.41; 2.086 GHz: 0.15, -0.48
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! magnitudes (dB):
! f  S11
! 100 kHz  -1.2
! 10.03 MHz  0.3
! 19.97 MHz  -0.5
! 39.83 MHz  -0.7
! 188.8 MHz  0.1
! 377.6 MHz  -0.6
! 556.4 MHz  -1.1
! 755 MHz  -0.7
! 923.9 MHz  -2.8
! 1.053 GHz  -1.7
! 1.133 GHz  -1.6
! 1.321 GHz  -2.7
! 1.5 GHz  -2.1
! 1.55 GHz  -1.9
! 1.669 GHz  -1.8
! 1.768 GHz  -2.9
! 1.818 GHz  -3.2
! 1.878 GHz  -2.8
! 1.887 GHz  -2.7
! 1.977 GHz  -1.7
! 2.086 GHz  -2.2
! 2.176 GHz  -2.6
! 2.255 GHz  -2.2
! 2.364 GHz  -1.1
! 2.632 GHz  -0.4
! 2.762 GHz  -0.6
! 2.94 GHz  0.6
! 3 GHz  0.3
